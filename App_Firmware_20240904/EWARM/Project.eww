<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BoardMachineV2024_enc.ewp</path>
  </project>
  <batchBuild />
</workspace>
