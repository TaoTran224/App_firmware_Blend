# IAR project BoardMachineV2024_enc.ewp, settings and files
configuration BoardMachineV2024_enc (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../FATFS/Target; ../FATFS/App; ../USB_HOST/App; ../USB_HOST/Target; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../App/Inc; ../App/Src; ../HAL/Ext_Driver/Inc; ../HAL/Ext_Driver/Src; ../HAL/Int_Driver/Inc; ../HAL/Int_Driver/Src; ../Common/Inc; ../Common/Src; ../BootLoader/Inc; ../BootLoader/Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BoardMachineV2024_enc.hex
  ILINK.IlinkOutputFile: BoardMachineV2024_enc.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/Inc
    ../App/Inc/: aes.h app.h button_func.h calculator.h File_Handling.h lcd.h process_data.h run_machine.h serial_func.h TI_aes_128.h usb.h
  group App/Src
    ../App/Src/: aes.c app.c button_func.c calculator.c File_Handling.c process_data.c run_machine.c serial_func.c TI_aes_128.c usb.c
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c i2c.c iwdg.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c
  group BootLoader/Inc
    ../BootLoader/Inc/: boot_loader.h flash.h
  group BootLoader/Src
    ../BootLoader/Src/: boot_loader.c flash.c
  group Common/Inc
    ../Common/Inc/: log.h
  group Common/Src
    ../Common/Src/: log.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group HAL/Ext_Driver/Inc
    ../HAL/Ext_Driver/Inc/: button.h buzzer.h cylinder.h cylinder_sensor.h emergency.h encoder.h led.h motor_billet.h motor_sawn.h motor_stepper.h optical_sensor.h signal_lights.h usb_process.h
  group HAL/Ext_Driver/Src
    ../HAL/Ext_Driver/Src/: button.c buzzer.c cylinder.c cylinder_sensor.c encoder.c led.c motor_billet.c motor_sawn.c motor_stepper.c optical_sensor.c signal_lights.c usb_process.c
  group HAL/Int_Driver/Inc
    ../HAL/Int_Driver/Inc/: board.h CLCD_I2C.h interrupt_process.h serial.h watchdog.h
  group HAL/Int_Driver/Src
    ../HAL/Int_Driver/Src/: board.c CLCD_I2C.c interrupt_process.c serial.c watchdog.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
